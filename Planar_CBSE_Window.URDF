Commit message: Better planar urdf

File: Planar_CBSE_Window.URDF (robot description, URDF)
Before this commit: robot Planar_CBSE_Window, 1 links, 0 joints
Links:
- link base_link: geometry collision sphere radius=0; collision sphere radius=0
